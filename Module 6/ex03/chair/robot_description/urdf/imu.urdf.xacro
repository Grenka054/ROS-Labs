Commit message: imu fix

File: Module 6/ex03/chair/robot_description/urdf/imu.urdf.xacro (robot description, xacro)
@@ -19,5 +19,4 @@
             <box size="0.02 0.05 0.05"/>
         </geometry>
-        <material name="pink"/>
     </visual>
     <collision>
